# Keil uVision project TivaClassDesign.uvprojx, settings and files
target Tiva_LCD_ADC_UART (6100001::V6.10.1::.\ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TivaClassDesign +hex
  c flags: Optim=7 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: rvmdk PART_TM4C123GH6PM
  c misc: -Wno-implicit-function-declaration -Wno-comment
  c include: ..\TivaClassDesign;.\inc;.\utils;.\driverlib;.\user;.\start-up
  asm define: rvmdk PART_TM4C123GH6PM
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group driverlib
    ./driverlib/rvmdk/: driverlib.lib
  group inc
    ./inc/: asmdefs.h hw_ints.h hw_memmap.h hw_types.h hw_uc1701.h hw_adc.h hw_aes.h hw_can.h hw_ccm.h hw_comp.h hw_des.h hw_eeprom.h hw_emac.h hw_epi.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_lcd.h hw_nvic.h hw_onewire.h hw_pwm.h hw_qei.h hw_shamd5.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h
  group start-up
    ./start-up/: startup_rvmdk.S
  group utils
    ./utils/: uartstdio.c uartstdio.h uc1701.c uc1701.h cpu_usage.c cpu_usage.h eeprom_pb.c eeprom_pb.h flash_pb.c flash_pb.h isqrt.c isqrt.h random.c random.h ringbuf.c ringbuf.h sine.c sine.h smbus.c smbus.h softi2c.c softi2c.h softssi.c softssi.h softuart.c softuart.h spi_flash.c spi_flash.h ustdlib.c ustdlib.h
  group user
    ./: main.c
software components: CMSIS:CORE 5.1.2
